<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>IQ_Demod</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>EECS</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>Modulator</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>IQ</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>gr_complex_to_arg</key>
<param><key>id</key><value>gr_complex_to_arg_1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>out1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_complex_to_arg</key>
<param><key>id</key><value>gr_complex_to_arg_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_transcendental</key>
<param><key>id</key><value>gr_transcendental_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>cos</value></param>
</block>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>gr_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gr_complex_to_arg_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>gr_transcendental_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
